## config/boards/shields/alpha34/kconfig.shield
```kconfig
# No whitespace after the comma or in your keyboard name!
config SHIELD_ALPHA34
    def_bool $(shields_list_contains,alpha34)
```
